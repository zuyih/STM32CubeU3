# Keil uVision project RTC_TrustZone_NS.uvprojx, settings and files
target RTC_TrustZone_NS (6210000::V6.21::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.0.0
  cpu: IRAM(0x20018000-0x2002FFFF) IROM(0x08080000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: RTC_TrustZone_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U385xx
  c include: ../../NonSecure/Inc;../../Secure_nsclib;../../../../../../../Drivers/BSP/STM32U3xx_Nucleo;../../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8080000 size 0x80000
  memory RVCT9: RAM 0x20030000 size 0x30000
  scatter file: RTC_TrustZone_NS\RTC_TrustZone_NS.sct
  link misc: ../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32u385xx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_exti.c stm32u3xx_hal_cortex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_icache.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32u3xx_ns.c
software components: CMSIS:CORE 5.6.0
