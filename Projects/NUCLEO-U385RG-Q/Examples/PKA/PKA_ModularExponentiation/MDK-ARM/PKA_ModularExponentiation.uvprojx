# Keil uVision project PKA_ModularExponentiation.uvprojx, settings and files
target PKA_ModularExponentiation (6140001::V6.14.1::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: PKA_ModularExponentiation +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U385xx
  c include: ../Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U3xx_Nucleo
  group Application/MDK-ARM
    ./: startup_stm32u385xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c plaintext.c ciphertext.c rsa_priv_2048.c rsa_pub_2048.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_exti.c stm32u3xx_hal_cortex.c stm32u3xx_hal_pka.c stm32u3xx_ll_pka.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_rng.c stm32u3xx_hal_rng_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
software components: CMSIS:CORE 5.6.0
