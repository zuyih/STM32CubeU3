<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DAC_ContinuousConversionDMA_TriggerEXTI.ewp</path>
  </project>
  <batchBuild />
</workspace>
