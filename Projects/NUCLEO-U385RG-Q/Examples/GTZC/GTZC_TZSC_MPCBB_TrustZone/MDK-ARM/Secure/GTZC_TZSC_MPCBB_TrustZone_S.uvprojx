# Keil uVision project GTZC_TZSC_MPCBB_TrustZone_S.uvprojx, settings and files
target GTZC_TZSC_MPCBB_TrustZone_S (6210000::V6.21::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.0.0
  cpu: IRAM(0x30000000-0x30007FFF) IROM(0x0C000000-0xC07DFFF) IROM2(0x0C07E000-0xC07FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: GTZC_TZSC_MPCBB_TrustZone_S +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U385xx,USER_VECT_TAB_ADDRESS,VECT_TAB_SRAM
  c include: ../../Secure/Inc;../../Secure_nsclib;../../../../../../../Drivers/BSP/STM32U3xx_Nucleo;../../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0xe000000 size 0x17000
  memory RVCT5: ROM 0xc07e000 size 0x2000
  memory RVCT9: RAM 0xe017000 size 0x1000
  scatter file: .\GTZC_TZSC_MPCBB_TrustZone_S\GTZC_TZSC_MPCBB_TrustZone_S.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32u385xx.s
  group Application/User/Secure
    ../../Secure/Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32u3xx_s.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_exti.c stm32u3xx_hal_cortex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_icache.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
software components: CMSIS:CORE 5.6.0
