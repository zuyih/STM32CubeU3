# IAR project GTZC_TZSC_MPCBB_TrustZone_NS.ewp, settings and files
configuration GTZC_TZSC_MPCBB_TrustZone_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385RG ST STM32U385RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U385xx; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ../../NonSecure/Inc; ../../Secure_nsclib; ../../../../../../../Drivers/BSP/STM32U3xx_Nucleo; ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GTZC_TZSC_MPCBB_TrustZone_NS.hex
  ILINK.IlinkOutputFile: GTZC_TZSC_MPCBB_TrustZone_NS.out
  ILINK.IlinkIcfFile: stm32u385xx_sram_ns.icf
  ILINK.IlinkAdditionalLibs: ../../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32u385xx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32u3xx_ns.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_exti.c stm32u3xx_hal_cortex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_icache.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
