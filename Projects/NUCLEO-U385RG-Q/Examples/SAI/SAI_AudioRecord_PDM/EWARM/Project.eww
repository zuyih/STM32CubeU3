<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SAI_AudioRecord_PDM.ewp</path>
  </project>
  <batchBuild />
</workspace>
