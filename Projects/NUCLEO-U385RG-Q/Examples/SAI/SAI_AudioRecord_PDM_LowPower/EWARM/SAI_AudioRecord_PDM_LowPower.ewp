# IAR project SAI_AudioRecord_PDM_LowPower.ewp, settings and files
configuration SAI_AudioRecord_PDM_LowPower (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385RG ST STM32U385RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U385xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U3xx_Nucleo; ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SAI_AudioRecord_PDM_LowPower.hex
  ILINK.IlinkOutputFile: SAI_AudioRecord_PDM_LowPower.out
  ILINK.IlinkIcfFile: stm32u385xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u385xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_cortex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_sai.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM33_IAR_wc32.a
