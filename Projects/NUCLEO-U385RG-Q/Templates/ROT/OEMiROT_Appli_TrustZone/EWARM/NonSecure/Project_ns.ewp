# IAR project Project_ns.ewp, settings and files
configuration NUCLEO-U385RG_OEMiROT_Appli_TrustZone_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385RG ST STM32U385RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U385xx
  ICCARM.CCIncludePath2: ..\..\NonSecure\Inc; ..\..\Secure_nsclib; ..\..\..\..\..\..\..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\Binary\oemirot_tz_ns_app.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32U385xx"
  postbuild: ..\postbuild.bat "nonsecure"
  ILINK.IlinkOutputFile: NUCLEO-U385RG.out
  ILINK.IlinkIcfFile: stm32u385xx_flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: ..\Secure\NUCLEO-U385RG_S\Exe\secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../NonSecure/Src/: startup_stm32u3xx.c
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32u3xx_ns.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
